# Keil uVision project binary_bcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: T80C51 Microchip
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: binary_bcd
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: binary_bcd.c
